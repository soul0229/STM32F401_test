# Keil uVision project STM32_LVGLV831.uvprojx, settings and files
target STM32_LVGLV831 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32_LVGLV831 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../lvgl;../lvgl/src/core;../lvgl/src/draw;../lvgl/src/draw/sdl;../lvgl/src/draw/sw;../lvgl/src/extra;../lvgl/src/extra/layouts;../lvgl/src/extra/layouts/flex;../lvgl/src/extra/layouts/grid;../lvgl/src/extra/libs;../lvgl/src/extra/libs/bmp;../lvgl/src/extra/libs/ffmpeg;../lvgl/src/extra/libs/freetype;../lvgl/src/extra/libs/fsdrv;../lvgl/src/extra/libs/gif;../lvgl/src/extra/libs/png;../lvgl/src/extra/libs/qrcode;../lvgl/src/extra/libs/rlottie;../lvgl/src/extra/libs/sjpg;../lvgl/src/extra/others;../lvgl/src/extra/others/fragment;../lvgl/src/extra/others/gridnav;../lvgl/src/extra/others/ime;../lvgl/src/extra/others/imgfont;../lvgl/src/extra/others/monkey;../lvgl/src/extra/others/msg;../lvgl/src/extra/others/snapshot;../lvgl/src/extra/themes;../lvgl/src/extra/themes/basic;../lvgl/src/extra/themes/default;../lvgl/src/extra/themes/mono;../lvgl/src/extra/widgets;../lvgl/src/extra/widgets/animimg;../lvgl/src/extra/widgets/calendar;../lvgl/src/extra/widgets/chart;../lvgl/src/extra/widgets/colorwheel;../lvgl/src/extra/widgets/imgbtn;../lvgl/src/extra/widgets/keyboard;../lvgl/src/extra/widgets/led;../lvgl/src/extra/widgets/list;../lvgl/src/extra/widgets/menu;../lvgl/src/extra/widgets/meter;../lvgl/src/extra/widgets/msgbox;../lvgl/src/extra/widgets/span;../lvgl/src/extra/widgets/spinbox;../lvgl/src/extra/widgets/spinner;../lvgl/src/extra/widgets/tabview;../lvgl/src/extra/widgets/tileview;../lvgl/src/extra/widgets/win;../lvgl/src/font;../lvgl/src/hal;../lvgl/src/misc;../lvgl/src/widgets;../lvgl/lv_driver;../lvgl/examples;../lvgl/examples/anim;../lvgl/examples/arduino;../lvgl/examples/assets;../lvgl/examples/event;../lvgl/examples/get_started;../lvgl/examples/layouts;../lvgl/examples/libs;../lvgl/examples/libs/bmp;../lvgl/examples/libs/ffmpeg;../lvgl/examples/libs/freetype;../lvgl/examples/libs/gif;../lvgl/examples/libs/png;../lvgl/examples/libs/qrcode;../lvgl/examples/libs/rlottie;../lvgl/examples/libs/sjpg;../lvgl/examples/others;../lvgl/examples/others/fragment;../lvgl/examples/others/gridnav;../lvgl/examples/others/ime;../lvgl/examples/others/imgfont;../lvgl/examples/others/monkey;../lvgl/examples/others/msg;../lvgl/examples/others/snapshot;../lvgl/examples/porting;../lvgl/examples/scroll;../lvgl/examples/styles;../lvgl/examples/widgets/animimg;../lvgl/examples/widgets/arc;../lvgl/examples/widgets/bar;../lvgl/examples/widgets/btn;../lvgl/examples/widgets/btnmatrix;../lvgl/examples/widgets/calendar;../lvgl/examples/widgets/canvas;../lvgl/examples/widgets/chart;../lvgl/examples/widgets/checkbox;../lvgl/examples/widgets/colorwheel;../lvgl/examples/widgets/dropdown;../lvgl/examples/widgets/img;../lvgl/examples/widgets/imgbtn;../lvgl/examples/widgets/keyboard;../lvgl/examples/widgets/label;../lvgl/examples/widgets/led;../lvgl/examples/widgets/line;../lvgl/examples/widgets/list;../lvgl/examples/widgets/menu;../lvgl/examples/widgets/meter;../lvgl/examples/widgets/msgbox;../lvgl/examples/widgets/obj;../lvgl/examples/widgets/roller;../lvgl/examples/widgets/slider;../lvgl/examples/widgets/span;../lvgl/examples/widgets/spinbox;../lvgl/examples/widgets/spinner;../lvgl/examples/widgets/switch;../lvgl/examples/widgets/table;../lvgl/examples/widgets/tabview;../lvgl/examples/widgets/textarea;../lvgl/examples/widgets/tileview;../lvgl/examples/widgets/win;../lvgl/demos;../lvgl/demos/benchmark;../lvgl/demos/benchmark/assets;../lvgl/demos/keypad_encoder;../lvgl/demos/music;../lvgl/demos/music/assets;../lvgl/demos/stress;../lvgl/demos/widgets;../lvgl/demos/widgets/assets;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group lv_core
    ../lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lv_draw
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lv_extra
    ../lvgl/src/extra/layouts/flex/: lv_flex.c
    ../lvgl/src/extra/layouts/grid/: lv_grid.c
    ../lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../lvgl/src/extra/others/monkey/: lv_monkey.c
    ../lvgl/src/extra/others/msg/: lv_msg.c
    ../lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../lvgl/src/extra/themes/default/: lv_theme_default.c
    ../lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../lvgl/src/extra/widgets/led/: lv_led.c
    ../lvgl/src/extra/widgets/list/: lv_list.c
    ../lvgl/src/extra/widgets/menu/: lv_menu.c
    ../lvgl/src/extra/widgets/meter/: lv_meter.c
    ../lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../lvgl/src/extra/widgets/span/: lv_span.c
    ../lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../lvgl/src/extra/widgets/win/: lv_win.c
    ../lvgl/src/extra/: lv_extra.c
    ../lvgl/src/extra/widgets/chart/: lv_chart.c
  group lv_font
    ../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lv_hal
    ../lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lv_widgets
    ../lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lv_driver
    ../lvgl/lv_driver/: lcd.c lv_port_disp.c w25qxx.c
  group lv_example
    ../lvgl/src/: lv_conf.h
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
software components: CMSIS:CORE 5.5.0
